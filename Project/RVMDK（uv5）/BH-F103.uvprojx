# Keil uVision project BH-F103.uvprojx, settings and files
target USART (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\encode;..\..\User\duoji;..\..\User\KEY;..\..\User\sys;..\..\User\Photoelectric;..\..\User\basetime;..\..\User\PIDNEW;..\..\User;..\RVMDK（uv5）
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h ALLCONFIG.c ALLCONFIG.h Location.c Location.h
    ../../User/usart/: bsp_usart.c
    ../../User/encode/: encode.c encode.h
    ../../User/duoji/: duoji.c duoji.h key.c key.h delay.c delay.h
    ../../User/sys/: sys.c sys.h
    ../../User/Photoelectric/: Photoelectric.c Photoelectric.h
    ../../User/basetime/: basetime.c basetime.h
    ../../User/PIDNEW/: pid.c pid.h
